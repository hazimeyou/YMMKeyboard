# Repository hazimeyou/YMMKeyboard

File README.md:

# YMMKeyboard

YMMKeyboard は、YukkuriMovieMaker 4 (YMM4) と連携する自作キーボードプロジェクトです。

このリポジトリでは、ハードウェア・ファームウェア・PC側処理・YMM4プラグインを一元管理しています。

## 特徴

- RP2040 ベースのコントローラ
- USB HID による入力連携
- CherryMX互換キーに対応
- キーはホットスワップ対応のソケットを実装
- YMM4 を選択してなくても入力操作対応

## 必要環境

- Windows 11
- YukkuriMovieMaker 4
- YMMKeyboard本体
- USB 接続環境

## インストール方法

- プラグイン: リリースリンク
- ファームウェア: リリースリンク

プラグインは`YMMKeyboardPlugin.ymme`を起動してください。
ファームウェアのアップデートは、未定です

## 使用方法

各ドキュメントを参照してください。

- [プラグイン](./ymm-plugin/src/YMMKeyboardPlugin/README.md)

- [ファームウェア](./firmware/src/RP2040TinyUsb/README.md)

## リポジトリ構成

- `hardware/` : 基板・筐体・部品・ハード補足資料
- `firmware/` : マイコン側実装
- `ymm-plugin/` : YMM4 プラグイン本体

## ライセンス

本リポジトリは MIT License です。詳細は [LICENSE](LICENSE) を参照してください。

## KiCad design KiCad/YMMkeyboardMX/YmmKeyboardMX.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31: 1N4148; D_SOD-123
H1, H2, H3, H4, H5, H6, H7, H8, H9: MountingHole; MountingHole_2.2mm_M2
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30: SW_Push; CherryMX_Hotswap_1u
SW31: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
U1: RP2040-Zero; RP2040-ZeroSocket

Connections:
+3.3V: U1.30 (3V3)
+5V: U1.32 (5V)
GND: SW31.C, U1.31 (GND)
unnamed: D1.2 (A), SW1.2
unnamed: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U1.28
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.27
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U1.26
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.15
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), U1.14
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.S2
unnamed: D31.1 (K), U1.29
unnamed: SW1.1, SW7.1, SW13.1, SW19.1, SW25.1, U1.8
unnamed: SW4.1, SW10.1, SW16.1, SW22.1, SW28.1, U1.5
unnamed: SW5.1, SW11.1, SW17.1, SW23.1, SW29.1, U1.4
unnamed: SW6.1, SW12.1, SW18.1, SW24.1, SW30.1, U1.3
unnamed: SW2.1, SW8.1, SW14.1, SW20.1, SW26.1, U1.7
unnamed: SW3.1, SW9.1, SW15.1, SW21.1, SW27.1, U1.6
unnamed: SW31.A, U1.0
unnamed: SW31.B, U1.1
unnamed: SW31.S1, U1.2

Board: 2 copper layers, 215.9 x 123.8 mm, 73 parts (31 on the bottom side), 47 nets.

Other parts of the board:
H7#2: MountingHole; MountingHole_2.2mm_M2

## KiCad design KiCad/YMMkeyboardRP/YMMkeyboardRP/YMMkeyboardRP.kicad_pcb

Parts:
C2, C3: 15p; C_0603_1608Metric
C5, C6, C7, C9, C11, C12, C13, C14, C15, C16: 100n; C_0603_1608Metric
C8, C10: 1u; C_0603_1608Metric
C17, C22, C23, C24, C25, C26: 10u; C_0603_1608Metric
C20, C21: 10u; C_0805_2012Metric
J1: Conn_01x20_Socket; PinHeader_1x20_P2.54mm_Vertical
J2: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J3: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical
J6: USB_B_Micro; USB_Micro-B_Molex_47346-0001
J7: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
JP1, JP2, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15, JP16, JP17: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1, R5: 1k; R_0603_1608Metric
R2: DNF; R_0603_1608Metric
R3, R4: 27; R_0603_1608Metric
R10, R12: 5.1k; R_0603_1608Metric
U1: XC6206PxxxMR; SOT-23
U2: W25Q32JVS; SOIC-8_5.3x5.3mm_P1.27mm
U3: RP2040; RP2040-QFN-56
U5, U7: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
Y1: ABM8-272-T3; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C6.1, C7.1, C8.1, U3.23 (DVDD), U3.45 (VREG_VOUT), U3.50 (DVDD)
+3V3: C5.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, JP1.2 (B), JP8.2 (B), JP9.2 (B), R2.1, U2.8 (VCC), U3.1 (IOVDD), U3.10 (IOVDD), U3.22 (IOVDD), U3.33 (IOVDD), U3.42 (IOVDD), U3.43 (ADC_AVDD), U3.44 (VREG_IN), U3.48 (USB_VDD), U3.49 (IOVDD)
/GPIO0: J1.20, U3.2 (GPIO0)
/GPIO1: J1.19, U3.3 (GPIO1)
/GPIO2: J1.18, U3.4 (GPIO2)
/GPIO3: J1.17, U3.5 (GPIO3)
/GPIO4: J1.16, U3.6 (GPIO4)
/GPIO5: J1.15, U3.7 (GPIO5)
/GPIO6: J1.14, U3.8 (GPIO6)
/GPIO7: J1.13, U3.9 (GPIO7)
/GPIO8: J1.12, U3.11 (GPIO8)
/GPIO9: J1.11, U3.12 (GPIO9)
/GPIO10: J1.10, U3.13 (GPIO10)
/GPIO11: J1.9, U3.14 (GPIO11)
/GPIO12: J1.8, U3.15 (GPIO12)
/GPIO13: J1.7, U3.16 (GPIO13)
/GPIO14: J1.6, U3.17 (GPIO14)
/GPIO15: J1.5, U3.18 (GPIO15)
/GPIO16: J1.4, U3.27 (GPIO16)
/GPIO17: J1.3, U3.28 (GPIO17)
/GPIO18: J1.2, U3.29 (GPIO18)
/GPIO19: J1.1, U3.30 (GPIO19)
/GPIO20: U3.31 (GPIO20)
/GPIO21: U3.32 (GPIO21)
/GPIO22: U3.34 (GPIO22)
/GPIO23: U3.35 (GPIO23)
/GPIO24: U3.36 (GPIO24)
/GPIO25: U3.37 (GPIO25)
/GPIO26_ADC0: U3.38 (GPIO26_ADC0)
/GPIO27_ADC1: U3.39 (GPIO27_ADC1)
/GPIO28_ADC2: U3.40 (GPIO28_ADC2)
/GPIO29_ADC3: U3.41 (GPIO29_ADC3)
/QSPI_SCLK: U2.6 (CLK), U3.52 (QSPI_SCLK)
/QSPI_SD0: U2.5 (DI/IO_{0}), U3.53 (QSPI_SD0)
/QSPI_SD1: U2.2 (DO/IO_{1}), U3.55 (QSPI_SD1)
/QSPI_SD2: U2.3 (~WP/IO_{2}), U3.54 (QSPI_SD2)
/QSPI_SD3: U2.7 (~HOLD/~RESET/IO_{3}), U3.51 (QSPI_SD3)
/QSPI_SS: R1.1, R2.2, U2.1 (~CS), U3.56 (QSPI_SS)
/RUN: J3.1, U3.26 (RUN)
/SWCLK: J3.2, U3.24 (SWCLK)
/SWD: J3.3, U3.25 (SWD)
/USB_D+: JP14.2 (B), JP15.2 (B), JP16.2 (B), R3.1
/USB_D-: JP10.2 (B), JP13.2 (B), JP17.2 (B), R4.1
/XIN: C2.1, U3.20 (XIN), Y1.1
/XOUT: R5.1, U3.21 (XOUT)
/~USB_BOOT: J2.1, R1.2
GND: C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, J2.2, J3.4, J6.5 (GND), J6.6 (Shield), J7.A1 (GND), J7.A12 (GND), J7.B1 (GND), J7.B12 (GND), J7.S1 (SHIELD), R10.2, R12.2, U1.1 (GND), U2.4 (GND), U3.19 (TESTEN), U3.57 (GND), U5.1 (GND), U7.1 (GND), Y1.2, Y1.4
unnamed: C3.1, R5.2, Y1.3
unnamed: J6.3 (D+), JP16.1 (A)
unnamed: J6.2 (D-), JP17.1 (A)
unnamed: C20.1, J6.1 (VBUS), JP2.1 (A), U5.3 (VI)
unnamed: J7.A5 (CC1), R10.1
unnamed: J7.B5 (CC2), R12.1
unnamed: C21.1, JP1.1 (A), U5.2 (VO)
unnamed: C23.1, JP8.1 (A), U7.2 (VO)
unnamed: C24.1, JP9.1 (A), U1.2 (VO)
unnamed: J7.A7 (D-), JP10.1 (A)
unnamed: C22.1, J7.A4 (VBUS), J7.A9 (VBUS), J7.B4 (VBUS), J7.B9 (VBUS), JP7.1 (A), JP11.1 (A), JP12.1 (A)
unnamed: C26.1, JP11.2 (B), U1.3 (VI)
unnamed: C25.1, JP12.2 (B), U7.3 (VI)
unnamed: J7.B7 (D-), JP13.1 (A)
unnamed: J7.B6 (D+), JP14.1 (A)
unnamed: J7.A6 (D+), JP15.1 (A)
unnamed: R4.2, U3.46 (USB_DM)
unnamed: R3.2, U3.47 (USB_DP)
VBUS: JP2.2 (B), JP7.2 (B)

Notes on the sheet:
公式Power
Make sure C10 is close to pin 44 of RP2040
Flash
Make sure R3 and R4 are close to RP2040
Make sure C8 is close to pin 45 of RP2040
USC-C置き換え版Power
Crystal
IOs

Board: 4 copper layers, 100.0 x 100.0 mm, 53 parts (0 on the bottom side), 56 nets.

## KiCad design KiCad/testboard/testboard/testboard.kicad_pcb

Board: 2 copper layers, 99.1 x 99.1 mm, 37 parts (0 on the bottom side), 26 nets, no tracks yet.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D4, D6, D8, D10, D12, D14, D16, D18: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D2, D3, D5, D7, D9, D11, D13, D15, D17: SK6812; LED_SK6812_PLCC4_5.0x5.0mm_P3.2mm
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9: SW_Push; CherryMX_Hotswap_1u
U1: RP2040-Zero; RP2040-ZeroSocket

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, D2.3 (VDD), D3.3 (VDD), D5.3 (VDD), D7.3 (VDD), D9.3 (VDD), D11.3 (VDD), D13.3 (VDD), D15.3 (VDD), D17.3 (VDD), U1.32 (5V)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D2.1 (VSS), D3.1 (VSS), D5.1 (VSS), D7.1 (VSS), D9.1 (VSS), D11.1 (VSS), D13.1 (VSS), D15.1 (VSS), D17.1 (VSS), U1.31 (GND)
unnamed: D1.2 (A), SW1.2
unnamed: D1.1 (K), D4.1 (K), D6.1 (K), U1.26
unnamed: D2.2 (DIN), U1.13
unnamed: D2.4 (DOUT), D3.2 (DIN)
unnamed: D3.4 (DOUT), D5.2 (DIN)
unnamed: D4.2 (A), SW2.2
unnamed: D5.4 (DOUT), D7.2 (DIN)
unnamed: D6.2 (A), SW3.2
unnamed: D7.4 (DOUT), D9.2 (DIN)
unnamed: D8.2 (A), SW4.2
unnamed: D10.2 (A), SW5.2
unnamed: D8.1 (K), D10.1 (K), D12.1 (K), U1.15
unnamed: D9.4 (DOUT), D11.2 (DIN)
unnamed: D11.4 (DOUT), D13.2 (DIN)
unnamed: D12.2 (A), SW6.2
unnamed: D13.4 (DOUT), D15.2 (DIN)
unnamed: D14.2 (A), SW7.2
unnamed: D14.1 (K), D16.1 (K), D18.1 (K), U1.14
unnamed: D15.4 (DOUT), D17.2 (DIN)
unnamed: D16.2 (A), SW8.2
unnamed: D18.2 (A), SW9.2
unnamed: SW1.1, SW4.1, SW7.1, U1.2
unnamed: SW2.1, SW5.1, SW8.1, U1.1
unnamed: SW3.1, SW6.1, SW9.1, U1.0

## Commit log

2026-01-24 .gitattributes、.gitignore、および LICENSE.txt を追加。
2026-01-24 プロジェクトファイルを追加。
2026-01-24 制限を追加
2026-01-25 プラグインを作成
2026-02-01 キーボードの設計ミスを変更 原因:ダイオードを直列に配置した結果電圧降下した
2026-02-01 ファームウェア多分完成
2026-02-01 kicadのバックアップ除外設定追加
2026-02-01 2号機発注データ
2026-02-03 いったん完成
2026-02-05 1fなら追加されるようになった
2026-02-07 RGBに対応
2026-02-08 なにしたっけ？
2026-02-08 いったんの最終版 ちゃんとシリアル通信で押した（回した）ところを送信できる奴
2026-02-08 とりあえずの完成版 mp3の追加とタイムラインのスクロールができる できないこと comポートの自動指定 mp3のフレーム数の自動指定
2026-02-11 ライセンスとREADMEを追加 READMEはまだ書いてない
2026-02-11 キーボード完成 LED追加するべき？
2026-02-11 設定画面を追加（昨日は無） ファイルを再構成
2026-02-11 ライセンスとREADME
2026-02-11 UTF-8に変更
2026-02-13 Revert "設定画面を追加（昨日は無）"
    This reverts commit 06e1c955e993fc517d6a8fdb53da2e81051d020f.
2026-02-19 3号機の発注
2026-02-19 3号機の発注（忘れてた）
2026-02-19 3号機のcadデータ
2026-02-19 テストボードを追加 MXキー用ホットスワップソケットとダイオードなどの干渉をテストするのに使います
2026-02-19 ライセンス関連
2026-02-21 テスト用キーボード（途中）
2026-02-23 3号機発注
2026-02-26 フォルダ分けとUI大幅変更
2026-02-26 CAD系
2026-02-27 キーボードの内部番号とUIの名部番号を見るためのクラス作成
2026-02-28 キー配置の統一完了
2026-02-28 設定追加（途中）
2026-02-28 開発PCの追加によるプロファイル追加と 不足していたライブラリ追加
2026-03-01 初期化失敗の修正
2026-03-02 設定関連
2026-03-10 YMMキーボード: 複数ポート/UID対応・割り当てUI刷新
    複数COMポート・複数デバイスUIDの同時管理に対応し、起動時自動接続や既知UIDリストを設定可能に。
    UIDごとにスイッチ割り当てを編集できる専用ウィンドウを追加し、アクションやパラメータの個別設定・テスト実行が可能に。
    設定画面を刷新し、COMポート選択・自動接続・手動テストUID選択・割り当て編集のUIを大幅拡張。
    設定保存形式をUID/スイッチ単位のJSONに変更し、永続化と正規化処理を追加。
    割り当てアクションは拡張性の高い方式にリファクタリングし
2026-03-11 キーボード割り当てをUI/実機UIDで分離・機能拡張
    キーボード割り当て設定を「UIキーボード」と「実機UID」ごとに個別管理できるよう大幅リファクタリングを実施。設定画面・割り当てウィンドウのUIも「対象」選択方式に変更し、説明文も整理。割り当て可能なアクションに「フレーム送り/戻し」を追加し、タイムライン操作が可能に。設定保存形式も新構造に対応し、全体的な命名や設計を整理・改善。
2026-03-11 プロジェクト構成・名前空間・UIを大規模リファクタリング
    MVVMパターンに沿ってModels/Actions/Views/Mapping等の名前空間・ディレクトリにクラスを再配置し、役割ごとに整理。KeyboardViewのボタンイベントを集約し、SwitchLayout/AssignmentItem等のモデルも分離。UI XAMLもViews配下に統一し、設定画面はYMMKeyboardSettingsPanelに一本化。CreateDefault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
2026-03-11 キーボード割り当て画面のUIを2ペイン方式に刷新
    従来のDataGridによる一覧編集から、左側に仮想キーボード、右側に選択中キーの詳細編集パネルを配置した2ペインUIに大幅リニューアルしました。各キーの割り当て状況が視覚的に分かりやすくなり、選択・編集・テスト実行が直感的に行えるようになりました。UIの配色や余白も調整し、操作性・可読性を向上させています。関連するイベントハンドラや状態管理ロジックも追加しています。
2026-03-11 複数キー組み合わせ割り当て・実行機能を追加
    キーボードプラグインに複数キー同時押し（コンビネーション）によるアクション割り当て・実行機能を追加しました。設定画面・実行画面ともに複数キー編集/実行モードを実装し、設定保存・UI・内部処理を大幅に拡張。単独キーと組み合わせキーの両方に柔軟なカスタマイズが可能となりました。
2026-03-12 YMMTカタログ読込機能追加＆UIリファイン
    YMM4プロジェクト(.ymmt)のcatalog.jsonを読み込む新機能（LoadYmmtCatalogAction）を追加し、テンプレートやアイテム情報のサマリー表示・プラグインフォルダへの保存に対応。YmmtCatalogLoaderやデータモデルも新規実装。キーマッピング・設定・キーボード各画面のXAMLをリファインし、余白・配色・フォント・ボタンサイズ等を調整、選択時の色をWindo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
2026-03-13 README.md の更新
2026-03-13 YM4カタログ読込の例外処理強化＆UI日本語化修正
    LoadYmmtCatalogAction.csで例外処理を強化し、各種エラー時のメッセージ表示を改善しました。また、YmmtCatalogLoader.csでint変換時のオーバーフロー対策を追加。KeyboardView.xamlおよびYMMKeyboardSettingsPanel.xamlの日本語UIテキストの文字化けを修正し、説明文やボタン名も分かりやすく日本語化しました。不要な旧実装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
2026-03-13 YMMTテンプレートのタイムライン自動インポート対応
    YMMT(.ymmt)ファイル読み込み時に、テンプレート内アイテムをタイムラインへ自動インポートする機能を追加。不明な型やファイル欠損時はスキップし、インポート結果をダイアログで表示。アクション名を日本語化し、「ymmt読み込み」選択時のみパラメータ欄にファイル参照ボタンを表示するなど、設定UIの利便性も向上。
2026-03-13 YMMTインポート時のfps差異対応と設定保存の改善
    YMMTカタログインポート時、テンプレートとタイムラインのfps差異を自動で補正し、アイテムのフレーム位置・長さをスケーリングするよう変更しました。fps取得処理やスケーリング用メソッドを追加し、タイミングのズレを防止します。また、KeyboardMappingWindowでウィンドウクローズ時に選択状態を保存するようOnClosingを実装しました。
2026-03-13 アクション名の正規化とFPS処理の精度向上
    アクション名を日本語・英語混在から英語表記に統一し、NormalizeActionNameメソッドで設定・UI・内部処理の一貫性を確保しました。旧日本語設定ファイルとの互換性も維持されます。また、FPS値の型をdouble化し、取得・計算・表示の精度を向上させました。これにより、設定ファイルやUIの互換性・信頼性が向上しています。
2026-03-16 UIレイアウトのコンパクト化と設定保存処理の強化
    UI各画面のサイズ・マージン・フォント等を調整し、よりコンパクトで見やすいレイアウトに変更。KeyboardAction, LegacyKeyboardViewModel に UndoRedoManager フィールドと未使用警告抑制を追加。RelayCommand の非同期コマンド対応を改善。YMMKeyboardSettings でスレッドセーフな保存、一時ファイル経由、ディープコピーによる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
2026-04-07 YMMTカタログ読込の堅牢化・詳細ログ機能を追加
    YMMKeyboardPluginの.ymmtカタログ読込処理を大幅に強化し、詳細なファイル/デバッグログ出力機能(PluginLogger)を新規実装。各種例外やインポート時の詳細な状態・理由をログに記録し、ShapeItem等の復元率向上のため多段階の型解決・プロパティ適用・パッチ処理を追加。YmmtItemSnapshotにRawJsonを保持し、復元失敗時の原因特定やデバッグが容易に。M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
2026-04-13 キーボードの制御部分を自作したい
2026-04-13 主要な配線終わった ピンにどうやって配線するんや
2026-05-24 rp2040の独自実装を検討
2026-05-24 ねじを締めたときに断線しそうなので修正
2026-05-24 README等編集
2026-05-24 ライセンスの修正
2026-05-29 エンコーダ入力の安定化と切断時状態クリアを修正し検証ツールを追加
2026-05-29 YMM4ライブラリをリポジトリ同梱から自動取得方式へ変更
2026-05-29 設定画面のシリアルポート取得を安全化し非Windows環境の例外を回避
2026-05-29 COMポート列挙にレジストリフォールバックを追加して認識率を改善
2026-05-29 配布DLLを必要最小限に整理し日本語文言とアクション名互換を修正
2026-05-29 デスクトップ版YMM4を既定参照にしてプラグイン自動配置を有効化
2026-05-29 表示文言の日本語化と文字化けの残りを修正
2026-05-29 System.IO.Ports同梱を停止してWindowsでのCOM接続例外を回避
2026-05-29 動作項目を日本語表示へ統一し旧設定名との互換を追加
2026-05-29 シーク操作をCommandSettings Seek Invoke経由へ変更し直接更新をフォールバック化
2026-05-29 実機通信とシーク処理を改善しRP2040転送と解析ログ出力を自動化
2026-05-29 診断ログの可搬化とSeek処理の精度・性能改善およびPorts参照の非固定化
2026-05-29 プラグイン全体を整理し未使用クラスと旧設定ビュー実装を削除
2026-05-29 実機受信行の正規化とUID検証を追加し不正UID混入による無効化を修正
2026-05-30 chore: reorganize repository files
2026-05-30 test: add unit tests for mapping and switch layout
2026-05-30 test: add ymmt catalog loader placement accuracy tests
2026-05-30 シーク経路の安定化と診断機能の強化
2026-05-30 シーク処理コードを整理し可読性を改善
2026-05-30 レビュー指摘対応: 文字化け修正と安定性改善
2026-05-31 Add template CreateItemsAsync probe to TestEvent
2026-05-31 Add template execution path to LoadYmmtCatalogAction and template picker UI
2026-05-31 Simplify TestEvent and harden template parameter UI behavior
2026-05-31 ドキュメントを一度コミット
2026-05-31 テンプレート読み込み機能
2026-05-31 USB HID診断機能と依存DLL自動配置を追加
2026-05-31 接続モード追加とHID入力リンク基盤を実装
2026-05-31 USB HID運用手順の日本語ドキュメントを追加
2026-05-31 HID安定化と製品名/メーカー名フィルタ設定を追加
2026-05-31 RP2040ファームをCustom HID+Serial同時送信に更新
2026-05-31 HID自動認識を強化しファーム送信にYMMKプレフィックスを追加
2026-05-31 HID列挙例外をデバイス単位で隔離しエラーログ連投を抑制
2026-05-31 HID失敗パスのクールダウンと自動診断サマリー出力を追加
2026-05-31 HID失敗パスをセッション除外し再試行ループを停止
2026-05-31 HID生レポートのデバッグログを追加して受信解析を強化
2026-05-31 HIDインターフェース選択をスコアリング化して受信対象を最適化
2026-05-31 HID試験用コンソール追加とCircuitPython複数IF試行ロジックを実装
2026-06-01 USB対応強化とRP2040自動ビルド環境を追加
2026-06-02 Add diagnostics RC2 CI verification
2026-06-02 feat: add macro diagnostics foundation
2026-06-02 feat: add dispatch diagnostics foundation
2026-06-02 feat: add unified diagnostics replay
    Solution update contains macro, dispatch, and replay project registrations.
2026-06-02 feat: add input diagnostics foundation
2026-06-02 feat: add input simulation foundation
2026-06-02 docs: freeze diagnostics foundation rc2
2026-06-02 fix: restore hid diagnostic identity fields
2026-06-02 docs: add hardware validation preparation
2026-06-02 feat: apply formal rp2040 identity
2026-06-02 fix: replace obsolete hidsharp device properties
2026-06-03 fix: stabilize hid identity diagnostics
2026-06-03 feat: add firmware hid send diagnostics
2026-06-03 docs: add hardware validation reports and dry run assets
2026-06-03 feat: add standalone hid console probe
2026-06-04 feat: continue matrix validation and docs
2026-06-04 docs: finalize reverse matrix scan direction
2026-06-04 fix: align formal matrix payload and plugin input path
2026-06-04 docs: update status for plugin inputreceived phase
2026-06-04 docs: record live plugin inputreceived validation
2026-06-04 fix: record dispatch execution baseline
2026-06-04 docs: align plugin input baseline
2026-06-04 docs: freeze working keyboard input baseline rc1
2026-06-04 docs: clarify rotary direction and multiple key mapping
2026-06-05 feat: confirm rotary host receive rc5
2026-06-05 fix: harden assignment saves and rotary payload contract
2026-06-05 chore: finalize cleanup rc1
2026-06-05 docs: record cleanup rc1 smoke test observations
2026-06-05 chore: mark serial path as legacy diagnostic fallback
2026-06-05 docs: prepare release rc1
2026-06-05 docs: prepare v0.1.0a release candidate
2026-06-05 docs: prepare public readme and release draft
2026-06-05 docs: freeze v0.1.0a rc1
2026-06-05 chore: remove obsolete docs before v0.1.0a release
2026-06-05 chore: minimize public code before v0.1.0a
2026-06-05 chore: remove diagnostic scripts before v0.1.0a
2026-06-05 chore: remove obsolete references for public master
2026-06-06 refactor: add runtime logging controls
2026-06-06 リポジトリ整理
2026-06-06 ガーバデータを削除
2026-06-06 完全オリジナルのRP2040実装版とテスト基板を削除
2026-06-06 ドキュメントを更新
2026-06-06 Fix plugin launch command in README
    Corrected the plugin launch command in the README.
2026-06-07 feat: refresh mapping and settings UI
2026-06-07 feat: add keyboard mapping filter
2026-06-07 実装の安定性と保守性を向上
2026-06-07 GitHub Actionsを更新
2026-06-07 バージョン抽出を修正
2026-06-07 Prepare Package Folder のコピー元を publish\plugin に変更
2026-06-07 Fix pico-sdk submodule fetch in release workflow
2026-06-07 Enable uf2 generation for firmware release
